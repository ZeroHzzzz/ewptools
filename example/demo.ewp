# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
configuration Release (ARM)
  as the first configuration, except:
  group Application
    src/: main.c
  group Application/drivers/spi
    src/drivers/spi/: driver_spi.c driver_spi.h
  group Application/drivers/uart
    src/drivers/uart/: driver_uart.c driver_uart.h
